# Keil uVision project ketCube.uvprojx, settings and files
target ketCube (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L072CZYx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IROM(0x08000000,0x00030000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: KETCUBE +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32L082xx,USE_B_L082Z_KETCube,USE_HAL_DRIVER, REGION_EU868,LOW_POWER_DISABLE,DEBUG
  c misc: --C99
  c include: ..\..\inc;..\..\..\Drivers\BSP\MLM32L07X01;..\..\..\Drivers\BSP\MLM32L07X01\Phy;..\..\..\Drivers\STM32L0xx_HAL_Driver\Inc;..\..\..\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\..\..\Drivers\CMSIS\Include;..\..\..\Middlewares\Third_Party\Lora\Crypto;..\..\..\Middlewares\Third_Party\Lora\Mac;..\..\..\Middlewares\Third_Party\Lora\Phy;..\..\..\Middlewares\Third_Party\Lora\Utilities;..\..\..\Middlewares\Third_Party\Lora\Core;..\..\..\Middlewares\Third_Party\Lora\Mac\region;..\..\..\KETCube\core;..\..\..\KETCube\modules\actuation;..\..\..\KETCube\modules\sensing;..\..\..\KETCube\modules\communication;..\..\..\Drivers\KETCube\core;..\..\..\Drivers\KETCube\modules
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Drivers/BSP/MLM32L0X01
    ../../../Drivers/BSP/MLM32L07X01/: mlm32l07x01.c
    ../../../Drivers/BSP/MLM32L07X01/Phy/: sx1276.c
  group Drivers/CMSIS
    ../../../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_spi.c stm32l0xx_hal_uart.c stm32l0xx_hal_adc.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2s.c
  group Projects/MDK-ARM
    ./: startup_stm32l072xx.s
  group Projects/Source
    ../../src/: debug.c hw_rtc.c hw_spi.c main.c mlm32l0xx_hal_msp.c mlm32l0xx_hw.c mlm32l0xx_it.c ketCube_cmdList.c ketCube_moduleList.c
  group Middlewares/Lora/Core
    ../../../Middlewares/Third_Party/Lora/Core/: lora.c
  group Middlewares/Lora/Mac
    ../../../Middlewares/Third_Party/Lora/Mac/: LoRaMac.c LoRaMacCrypto.c
  group Middlewares/Lora/Mac/Regions
    ../../../Middlewares/Third_Party/Lora/Mac/region/: Region.c RegionAS923.c RegionAU915.c RegionCN470.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionUS915.c RegionUS915-Hybrid.c
  group Middlewares/Lora/Utilities
    ../../../Middlewares/Third_Party/Lora/Utilities/: delay.c low_power.c timeServer.c utilities.c
  group Middlewares/Lora/Crypto
    ../../../Middlewares/Third_Party/Lora/Crypto/: aes.c cmac.c
  group KETCube/core
    ../../../KETCube/core/: ketCube_cfg.c ketCube_cfg.h ketCube_common.c ketCube_common.h ketCube_modules.c ketCube_modules.h ketCube_terminal.c ketCube_terminal.h ketCube_rxDisplay.c ketCube_rxDisplay.h ketCube_coreCfg.c ketCube_coreCfg.h ketCube_asyncTx.c ketCube_asyncTx.h ketCube_core_cmd.c
  group KETCube/modules/communication
    ../../../KETCube/modules/communication/: ketCube_lora.c ketCube_lora.h ketCube_lora_cmd.c ketCube_starNet.c ketCube_starNet.h ketCube_txDisplay.c ketCube_txDisplay.h ketCube_lora_ext.c ketCube_lora_ext.h
  group KETCube/modules/sensing
    ../../../KETCube/modules/sensing/: ketCube_adc.c ketCube_adc.h ketCube_bmeX80.c ketCube_bmeX80.h ketCube_fdc2214.c ketCube_fdc2214.h ketCube_hdc1080.c ketCube_hdc1080.h ketCube_ics43432.c ketCube_ics43432.h ketCube_lis2hh12.c ketCube_lis2hh12.h ketCube_batMeas.c ketCube_batMeas.h ketCube_batMeas_cmd.c
  group KETCube/drivers/core
    ../../../Drivers/KETCube/core/: ketCube_eeprom.c ketCube_eeprom.h ketCube_uart.c ketCube_uart.h ketCube_gpio.c ketCube_gpio.h
  group KETCube/drivers/modules
    ../../../Drivers/KETCube/modules/: ketCube_i2c.c ketCube_i2c.h ketCube_i2s.c ketCube_i2s.h ketCube_mainBoard.h ketCube_timer.c ketCube_timer.h
